# IAR project Gpio_LedBlinky.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Burst.srec
  ILINK.IlinkOutputFile: Gpio_LedBlinky.out
configuration SPIFI Flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  OBJCOPY.OOCOutputFile: Gpio_LedBlinky.srec
configuration Hitex Flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
configuration Internal Flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_M4; INTERNAL_FLASH; SKIP_SPIFI_INIT
  OBJCOPY.OOCOutputFile: Gpio_LedBlinky.srec
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0x00000000-0x0000001B "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$_cksum.out"
  group CMSIS-CM4
    ../../../../Core/Device/NXP/LPC43xx/Source/: fpu_enable.c
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_lpc43xx.c
  group Drivers
    ../../../../Drivers/source/: lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_uart.c
  group Main
    ../: Gpio_LedBlinky.c Hitex_Fast_Startup.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_lpc43xx.s
