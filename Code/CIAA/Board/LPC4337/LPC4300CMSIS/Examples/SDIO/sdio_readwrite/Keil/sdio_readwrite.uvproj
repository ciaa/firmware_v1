# Keil uVision project sdio_readwrite.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Adc_Interrupt
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: lpc43xx_scu.c lpc43xx_cgu.c debug_frmwrk.c lpc43xx_sdif.c lpc43xx_sdmmc.c lpc43xx_timer.c lpc43xx_uart.c
  group Main
    ../: Sdio_readwrite.c
  group Readme
    ../: abstract.txt
