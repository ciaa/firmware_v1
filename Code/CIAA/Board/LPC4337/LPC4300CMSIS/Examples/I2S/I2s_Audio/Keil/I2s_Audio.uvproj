# Keil uVision project I2s_Audio.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Adc_Interrupt
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10080000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc43xx_uart.c lpc43xx_scu.c lpc43xx_i2s.c lpc43xx_i2c.c lpc43xx_cgu.c lpc43xx_gpio.c
  group Main
    ../: I2s_Audio.c audiodata.c
  group Readme
    ../: abstract.txt
target SPIFI 64MB Debug (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\SPIFI 64MB Debug.sct
target Hitex Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Hitex Flash.sct
