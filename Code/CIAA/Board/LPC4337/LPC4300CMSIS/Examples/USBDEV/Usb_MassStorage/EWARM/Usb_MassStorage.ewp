# IAR project Usb_MassStorage.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Burst.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\example\Hitex-LPC43xx_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM4
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_lpc43xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc43xx_cgu.c lpc43xx_scu.c lpc43xx_uart.c
  group Main
    ../: DiskImg.c memory.c mscuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_lpc43xx.s
