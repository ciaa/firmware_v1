# Keil uVision project SGPIO.uvproj, settings and files
target LPC43xx RAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: sgpio_spi_master +hex
  AfterMake: fromelf --bin -o $L@L.bin $L@L.axf
  c flags: OneElfS=1
  c define: CORE_M4
  c misc: --c99
  c include: .\system
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\M4_Ram.sct
  group Startup Code
    ./system/: startup_LPC43xx.s
  group System Code
    ./system/: fpu_init.c lpc43xx_cgu.c lpc43xx_scu.c system_LPC43xx.c
  group Source Code
    ./: sgpio_spi.c main.c SGPIO_makeMaster0Cpha0HighConfig.c SGPIO_makeMaster0Cpha0LowConfig.c SGPIO_makeMaster0Cpha1HighConfig.c SGPIO_makeMaster0Cpha1LowConfig.c SGPIO_makeMaster1Cpha0HighConfig.c SGPIO_makeMaster1Cpha0LowConfig.c SGPIO_makeMaster1Cpha1HighConfig.c SGPIO_makeMaster1Cpha1LowConfig.c
  group Documentation
    ./: Abstract.txt
