# Keil uVision project hs_PG_M0.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: sgpio_pg +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 oTime=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Adc_Interrupt
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT5: ROM 0x20009000 size 0x1000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x2000a000 size 0x1000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: lpc43xx_scu.c lpc43xx_cgu.c lpc43xx_gpdma.c lpc43xx_gpio.c
  group Main
    ../: Sgpio_pg.c main_M4.c setup_M0.c
  group Readme
    ../: abstract.txt
target SPIFI 64MB Debug (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 HITEX_LCD_TERM DEBUG
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x14000000 size 0x100000
  memory RVCT9: RAM 0x10080000 size 0xa000
target SPIFI 128MB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 HITEX_LCD_TERM DEBUG
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10400000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x18000
target Hitex Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 HITEX_LCD_TERM DEBUG
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x400000
  memory RVCT9: RAM 0x10800000 size 0xa000
