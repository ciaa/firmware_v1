<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Gpdma_LinkList.ewp</path>
  </project>
  <batchBuild/>
</workspace>


