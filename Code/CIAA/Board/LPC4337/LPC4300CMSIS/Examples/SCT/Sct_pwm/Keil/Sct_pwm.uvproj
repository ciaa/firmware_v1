# Keil uVision project Sct_pwm.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Sct_SimpleMatch +hex
  c flags: Optim=1
  c define: CORE_M4 USE_FPU
  c misc: --c99
  c include: .\;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Sct_SimpleMatch;..\driver;..\platform
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10080000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
    ../../../../Core/Device/NXP/LPC43xx/Source/: fpu_enable.c
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: lpc43xx_uart.c lpc43xx_scu.c lpc43xx_sct.c lpc43xx_gpio.c lpc43xx_emc.c
  group SCT
    ../driver/: sct_pwm.c sct_hal.c pwm_debugOutput.c pwm_push_pull.c pwm_push_pull_complementary.c pwm_single_phase.c pwm_single_phase_complementary.c pwm_pulse_skipping.c pwm_var_frequency.c pwm_pulse_skipping_complementary.c
  group Main
    ../: SCT_pwm_test.c
  group Readme
    ../: Abstract.txt
  group platform
    ../platform/: mcb4300_lpc4350.c lpc43xx_cgu.c
