# Keil uVision project Usb_MassStorage.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 HITEX_LCD_TERM DEBUG
  c misc: --c99
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Usb_MassStorage
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group System Code
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../../../../Drivers/source/: lpc43xx_scu.c lpc43xx_cgu.c sdio.c debug_frmwrk.c Font5x7.c LCDTerm.c lpc43xx_uart.c lpc43xx_gpio.c lpc43xx_ssp.c
  group Source code
    ../: main.c mem_usbdesc.c usbd_msc_sdio.c
  group Readme
    ../: Abstract.txt
target SPIFI 64MB Debug (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4  HITEX_LCD_TERM DEBUG
  c misc: --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x14000000 size 0x100000
  memory RVCT9: RAM 0x10080000 size 0xa000
target SPIFI 128MB (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4  HITEX_LCD_TERM DEBUG
  c misc: --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x100000
  memory RVCT9: RAM 0x10080000 size 0xa000
target Hitex Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4  HITEX_LCD_TERM DEBUG
  c misc: --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x400000
  memory RVCT9: RAM 0x10080000 size 0xa000
