# IAR project Usb_MassStorage.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; HITEX_LCD_TERM; DEBUG
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Burst.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\example\Hitex-LPC43xx_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SPIFI 64MB Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\example\Hitex-LPC43xx_spifi_0x14000000.icf
configuration SPIFI 128MB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\example\Hitex-LPC43xx_spifi_0x80000000.icf
configuration Hitex Flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\example\Hitex-LPC43xx_norflash.icf
  group CMSIS-CM4
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_lpc43xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c Font5x7.c LCDTerm.c lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_uart.c sdio.c
  group Main
    ../: main.c mem_usbdesc.c usbd_msc_sdio.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_lpc43xx.s
