# Keil uVision project SPIFI_Lcd.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c misc: --c99
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Adc_Interrupt
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_cgu.c lpc43xx_lcd.c lpc43xx_emc.c lpc43xx_adc.c
  group Main
    ../: Hitex_Fast_Startup.c graphic_resources.c Lcd_Demo.c
    ../../../../Drivers/lib/: spifi_drv_M4.lib
  group Readme
    ../: abstract.txt
target Hitex Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c misc: --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x400000
  memory RVCT6: RAM 0x28000000 size 0x800000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x18000
  scatter file: ..\Hitex Flash.sct
target Program Image to SPIFI (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  c flags: Optim=1
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x1ffff
  memory RVCT5: ROM 0x80000000 size 0x100000
  memory RVCT9: RAM 0x10080000 size 0xa000
