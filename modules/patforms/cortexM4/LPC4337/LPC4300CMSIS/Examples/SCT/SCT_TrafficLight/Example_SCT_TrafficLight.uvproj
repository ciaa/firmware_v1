# Keil uVision project Example_SCT_TrafficLight.uvproj, settings and files
target LPC43xx Internal SRAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1
  c define: LPC43XX CORE_M4 HITEX_LCD_TERM
  c include: .\;.\inc;..\..\..\Core\CMSIS\Include;..\..\..\Drivers\include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10080000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: tlight.inc pedestrian_tlight.fzm sct_fsm.c
    ./src/: SCT_TrafficLight.c
  group root
    ./: abstract.txt
  group CMSIS-CM4
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Startup
    ./src/: Hitex_Fast_Startup.c
    ../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group Drivers
    ../../../Drivers/source/: lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpio.c lpc43xx_uart.c lpc43xx_sct.c lpc43xx_scu.c
target LPC43xx SPIFI 64MB Debug (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1
  c define: LPC43XX CORE_M4 HITEX_LCD_TERM
  c include: .\;.\inc;..\..\..\Drivers\include;..\..\..\Core\CMSIS\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\keil\SPIFI 64MB Debug.sct
target LPC43xx 39VF3201B Flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1
  c define: LPC43XX CORE_M4 HITEX_LCD_TERM EXT_FLASH
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\keil\Hitex Flash.sct
