# Keil uVision project M0.uvproj, settings and files
target LPC43xx_M0_RAM (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_RAM +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\RAM_M0\CM0_RAM.axf"
  c flags: OneElfS=1
  c define: CORE_M0 IPC_SLAVE
  c include: ..\..\..\..\Drivers\include;..\platform;..\M0\M0_rpc;..\M4\M4_rpc;..\..\..\..\Core\Device\NXP\LPC43xx\Include
  asm define: NO_CRP IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: .\link-CM0.sct
  link misc: --pad=0xFF
  group System Code
    ../../../../Drivers/source/: lpc43xx_scu.c
    ../platform/: startup_LPC43xx.c
  group Ipc
    ../../../../Drivers/source/: ipc_int.c
    ../M0/M0_rpc/: slave_interrupt_callback.c
  group Platform
    ../platform/: platform_init.h
  group Source Code
    ../M0/: main.c
target LPC43xx_M0_Flash (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CM0_FLASH +hex
  AfterMake: fromelf --cadcombined --output="..\M4\M0_image\CM0_image.c" ".\FLASH_M0\CM0_FLASH.axf"
  c flags: OneElfS=1
  c define: CORE_M0 IPC_SLAVE BOOT_FROM_INTERNAL_FLASH
  c include: as above
  asm define: NO_CRP IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x200
  memory RVCT9: RAM 0x18000200 size 0xe00
  memory RVCT10: RAM 0x18001000 size 0x1000
  scatter file: .\link-CM0_flash.sct
  link misc: --pad=0xFF
