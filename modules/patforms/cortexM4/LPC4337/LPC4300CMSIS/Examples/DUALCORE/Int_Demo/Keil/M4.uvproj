# Keil uVision project M4.uvproj, settings and files
target LPC43xx_M4_RAM (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: LPC43xx_M4_RAM +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER
  c misc: --c99
  c include: ..\M4\M4_rpc;..\M0\M0_rpc;..\M4\M0_image;..\..\..\..\Drivers\include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\platform
  asm define: NO_CRP IPC_MASTER
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\link-M4_Ram.sct
  link misc: --debug --pad=0xFF
  group System Code
    ../platform/: system_LPC43xx.c startup_LPC43xx.c
  group Ipc
    ../../../../Drivers/source/: ipc_int.c
  group Platform
    ../platform/: platform_init.c lpc43xx_cgu.c keil_board_init.c
    ../../../../Core/Device/NXP/LPC43xx/Source/: fpu_enable.c
  group Source Code
    ../M4/: main.c
    ../M4/M4_rpc/: master_interrupt_callback.c
    ../: abstract.txt
  group Drivers
    ../../../../Drivers/source/: lpc43xx_scu.c
    ../../../../Drivers/lib/: spifi_drv_M4.lib
target LPC43xx_M4_FLASH (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_FLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER USE_NOR_FLASH BOOT_FROM_NORFLASH
  c misc: --c99
  c include: ..\..\..\..\Drivers\include;..\M0\M0_rpc;..\M4\M4_rpc;..\platform;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\M4\M0_image
  asm define: NO_CRP
  library: MicroLIB
  scatter file: .\link-M4_Flash.sct
  link misc: --debug --pad=0xFF
target LPC43xx_M4_SPIFI (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_SPIFI_program +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER BOOT_FROM_SPIFI USE_SPIFI_LIB
  c misc: --c99
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  scatter file: .\link-M4_Spifi.sct
  link misc: --debug --pad=0xFF
target LPC43xx_M4_internal_flash (ARM-ADS)
  device: LPC4350 NXP (founded by Philips)
  cpu: as above
  output: LPC43xx_M4_INTFLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M4 IPC_MASTER BOOT_FROM_INTERNAL_FLASH
  c misc: --c99
  c include: as above
  asm define: NO_CRP IPC_MASTER
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\link-M4_internal_flash.sct
  link misc: --debug --pad=0xFF
