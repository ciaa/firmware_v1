# Keil uVision project SPIFI_Test.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 USE_SPIFI_LIB
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Drivers\include;..\..\Adc_Interrupt
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    ../../../../Drivers/source/: lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_cgu.c debug_frmwrk.c lpc43xx_uart.c
    ../../../../Drivers/lib/: spifi_drv_M4.lib
  group Main
    ../: Spifi_Test.c
  group Readme
    ../: abstract.txt
target Hitex Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4 USE_SPIFI_LIB
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x400000
  memory RVCT9: RAM 0x10080000 size 0xa000
