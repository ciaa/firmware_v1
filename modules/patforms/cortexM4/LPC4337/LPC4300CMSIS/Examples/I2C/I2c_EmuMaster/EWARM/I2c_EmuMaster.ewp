# IAR project I2c_EmuMaster.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\lpc43xx\Include; ..\..\..\..\Drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Burst.srec
  ILINK.IlinkOutputFile: I2c_Master.out
  ILINK.IlinkIcfFile: Internal SRAM\I2c_Master.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM4
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/: system_lpc43xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc43xx_cgu.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_uart.c
    ../: m24xx.c
  group Main
    ../: i2c_bitbanging.c I2c_EmuMaster.c pca9532.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC43xx/Source/Templates/IAR/: startup_lpc43xx.s
