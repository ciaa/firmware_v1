# Keil uVision project SGPIO_I2S_Audio.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3
  c define: CORE_M4 , UDA1380
  c misc: --diag_suppress 188
  c include: ..\usbd;..\..\USB-Audio-Demo;..\..\..\..\Drivers\include;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC43xx\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  group Startup
    C:/Users/dep00717/Programs/Keil/Projects/CMSIS/USB_Audio_HitexA4_v1/Core/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CMSIS-CM3
    C:/Users/dep00717/Programs/Keil/Projects/CMSIS/USB_Audio_HitexA4_v1/Core/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group Drivers
    C:/Users/dep00717/Programs/Keil/Projects/CMSIS/USB_Audio_HitexA4_v1/Drivers/source/: lpc43xx_gpio.c lpc43xx_scu.c lpc43xx_cgu.c lpc43xx_i2c.c
    ../: lpc43xx_emc_init.c
  group Main
    ../: main.c adc_desc.c adc_user.c codec.c sgpio_i2s.c usbd_adc.c uda1380.c
  group Readme
    ../: abstract.txt
target SPIFI 64MB Debug (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3
  c define: CORE_M4 , UDA1380
  c misc: --diag_suppress 188
  c include: ..\usbd;..\..\USB-Audio-Demo;..\..\..\..\Drivers\include;..\..\..\..\Core\Device\NXP\LPC43xx\Include;..\..\..\..\Core\CMSIS\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x14000000 size 0x800000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x10080000 size 0xa000
  scatter file: .\SPIFI 64MB Debug.sct
target Hitex Flash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3
  c define: CORE_M4 , EXT_STAT_MEM , UDA1380
  c misc: --diag_suppress 188
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1c000000 size 0x400000
  memory RVCT9: RAM 0x10080000 size 0xa000
  scatter file: .\Hitex Flash.sct
